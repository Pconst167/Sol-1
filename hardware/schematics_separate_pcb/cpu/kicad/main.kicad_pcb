# Repository Pconst167/Sol-1

File readme.md:

# Sol-1 Homebrew Minicomputer

Sol-1 is a homebrew CPU and Minicomputer built from 74HC logic.
It is published here for educational purposes.

### Directory Struture
| Folder Name | Description |
| ------------- | ----------- |
| ccompiler     | a c compiler written for the Sol-1 CPU. It outputs Sol-1 assembly |
| hardware      | schematics, board pictures, microcode assembler |
| software      | bios, kernel, shell, and unix utilities programs written in ASM for Sol-1 |
| emulator      | an emulator for Sol-1. |
| solix         | the operating system for Sol-1 |
| solfs         | a disk image generator for Sol-1 |
| systemverilog | systemverilog models for the Sol-1 CPU, computer, and a few other things |
| general_docs  | datasheets and miscellaneous documents related to Sol-1 and digital design in general | 
| sol1_docs     | documents directly related to Sol-1 | 

## Features
### Hardware
- User and Kernel privilege modes, with up to 256 processes.
- Paged virtual memory, such that each process can have a total of 64KB RAM for itself.
- Two serial ports (16550), a real time clock(M48T02), 2 parallel ports(8255), a programmable timer(8253), an IDE hard-drive interface(2.5 Inch HDD), a sound chip(AY-3-8910),
5.25" floppy drive controller (WD1770).
- 8 prioritized external interrupts
- DMA channel
- The sequencer is microcoded, with 15 ROMS operating horizontally
- 8/16-Bit MUL and DIV instructions
- Fast indexed string instructions in the spirit of x86's REP MOVSB, CMPSB, LODSB, STOSB, etc
- 32bit IEEE 754 Floating Point Unit (Under Development)
- 5.25" floppy drive :)

### Register Table
#### General Purpose Registers

| 16bit | 8bit  | Description |
| ----- | ----- | ----------- |
| A     | AH/AL | Accumulator |
| B     | BH/BL | Base Register (Secondary Counter Register) |
| C     | CH/CL | Counter Register (Primary Counter) |
| D     | DH/DL | Data Register / Data Pointer |
| G     | GH/GL | General Register (For scratch) |

#### Special Purpose Registers

| 16bit  | 8bit   | Description |
| ------ | ------ | ----------- |
| PC     |        | Program Counter |
| SP     |        | Stack Pointer |
| SSP    |        | Supervisor Stack Pointer |
| BP     |        | Base Pointer (Used to manage stack frames) |
| SI     |        | Source Index (Source address for string operations) |
| DI     |        | Destination Index (Destination address for string operations) |
| PTB    |        | Page Table Base |
| Status |        | CPU Status |
| Flags  |        | Arithmetic and Logic flags register |

### Software
- Unix-like operating system (in progress and very early)
- C compiler that generates a Sol-1 assembly output file
- SystemVerilog model
- Emulator

[Video demonstrations here](https://www.youtube.com/@PauloConstantino167/videos)

### Licensing Terms

Copyright © 2026 Paulo Constantino

This work is licensed under the Creative Commons Attribution-NonCommercial 4.0 International License (CC BY-NC 4.0).

You are free to use, copy, modify, and redistribute this work for non-commercial purposes, provided appropriate credit is given.

Commercial use is not permitted.

License:
https://creativecommons.org/licenses/by-nc/4.0/

## KiCad design hardware/schematics_whole/kicad/main.kicad_pcb

Schematic: main.kicad_sch

Parts:
ALU_HIGH1: 74181N; DIP-24_W7.62mm
ALU_LOW1: 74181N; DIP-24_W7.62mm
BIOS_ROM1: 27512; DIP-28_W15.24mm
DIS1, DIS2: TIL311
FLAGS1: 74273N; DIP-20_W7.62mm
IC1, IC2, IC36, IC42, IC54, IC55, IC56, IC57, IC58, IC59, IC60, IC61, IC62, IC63, IC64, IC65, IC66, IC67, IC68, IC69, IC70, IC71, IC72, IC73, IC74, IC84, IC85, IC114, IC195: 74377N; DIP-20_W7.62mm
IC3, IC4, IC5, IC6, IC31, IC32, IC33, IC34: 74253N; DIP-16_W7.62mm
IC7, IC8, IC9, IC10, IC14, IC17, IC18, IC77, IC78, IC79, IC80, IC81, IC82, IC83, IC87, IC89, IC166, IC167, IC168, IC169: 74153N; DIP-16_W7.62mm
IC11, IC12, IC15, IC16, IC19, IC20, IC24, IC25, IC26, IC27, IC30, IC76, IC93, IC111, IC112, IC155, IC156, IC157, IC158, IC159, IC160, IC190, IC191: 74257N; DIP-16_W7.62mm
IC13, IC35, IC161: 7408N; DIP-14_W7.62mm
IC21, IC43, IC113, IC121, IC163, IC194: 7404N; DIP-14_W7.62mm
IC22, IC91, IC92, IC96, IC97, IC98, IC99, IC100, IC101, IC102, IC103, IC104, IC105, IC106, IC107, IC108: 74273N; DIP-20_W7.62mm
IC23: 7410N; DIP-14_W7.62mm
IC28, IC49, IC50, IC88, IC90, IC123, IC124, IC125, IC126, IC127, IC128, IC129, IC130, IC131, IC132, IC133, IC134, IC135, IC136, IC137, IC138, IC139, IC140, IC141, IC142, IC143, IC144, IC145, IC146, IC147, IC148, IC149, IC150, IC151, IC152, IC153, IC154: 74151N; DIP-16_W7.62mm
IC29, IC53: 7432N; DIP-14_W7.62mm
IC37: 7486N; DIP-14_W7.62mm
IC38, IC39, IC40, IC41: 74283N; DIP-16_W7.62mm
IC44, IC45, IC48, IC171, IC188, IC192: 7432N; DIP-14_W7.62mm; MPN SN7432N
IC46, IC52: 7400N; DIP-14_W7.62mm
IC47, IC115, IC117, IC118, IC119, IC120, IC172, IC173, IC174, IC179, IC180, IC185, IC186, IC196, IC197, IC198, IC200, IC202, IC204, IC206: 74244N; DIP-20_W7.62mm
IC51, IC109, IC165: 7427N; DIP-14_W7.62mm
IC75: 7411N; DIP-14_W7.62mm
IC86, IC116, IC176, IC199: 74138N; DIP-16_W7.62mm
IC110: 74245N; DIP-20_W7.62mm
IC122: 7420N; DIP-14_W7.62mm
IC162: 7430N; DIP-14_W7.62mm
IC164, IC170: 7474N; DIP-14_W7.62mm
IC175, IC187: 74279N; DIP-16_W7.62mm
IC181, IC182, IC183, IC184: 74157N; DIP-16_W7.62mm
IC189, IC193, IC201: DIL14
IC_02_1: 7402N; DIP-14_W7.62mm
IC_04_1: 7404N; DIP-14_W7.62mm
IC_10_1, IC_10_2: 7410N; DIP-14_W7.62mm
IC_86_1, IC_86_2: 7486N; DIP-14_W7.62mm
IRQ_0_DFF1, IRQ_1_DFF1, IRQ_2_DFF1, IRQ_3_DFF1: 7474N; DIP-14_W7.62mm
IRQ_AND_1, IRQ_AND_2: 7408N; DIP-14_W7.62mm
IRQ_CODE1: 74377N; DIP-20_W7.62mm
IRQ_ENCODER1: 74148N; DIP-16_W7.62mm
IRQ_RST_DECODER1: 74138N; DIP-16_W7.62mm
IRQ_STATUS_1: 74273N; DIP-20_W7.62mm
J1: Conn_02x17_Odd_Even
KM62256CLP1: KM62256CLP; DIP-28_W15.24mm
MARH1: 74377N; DIP-20_W7.62mm
MARL1: 74377N; DIP-20_W7.62mm
MDRH1: 74377N; DIP-20_W7.62mm
MDRL1: 74377N; DIP-20_W7.62mm
MDR_IN_MUX_1, MDR_IN_MUX_2: 74157N; DIP-16_W7.62mm
MDR_OUT_MUX_1, MDR_OUT_MUX_2: 74157N; DIP-16_W7.62mm
PAGE_TABLE_RAM_0, PAGE_TABLE_RAM_1: 58C256P; DIP-28_W15.24mm
PIO_0: 8255; DIP-40_W15.24mm
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9: R_Pack08; DIP-16_W7.62mm
S1: 100SP1T1B4M2QE; SW_100SP1T1B4M2QE; PARTREV E
SW1, SW11, SW12, SW13: SW_SPST; SW_100SP1T1B4M2QE
SW2, SW4, SW5, SW6, SW7, SW8, SW9, SW10: SW_DIP_x08; DIP-16_W7.62mm
U1, U2, U3, U4, U5, U6, U7, U8: as6c4008-55pcn; DIP-32_W15.24mm
U9: M48T02-200PC1; DIP-24_W15.24mm
U10: 8253; DIP-24_W15.24mm_Socket
U11: 74LS06; DIP-14_W7.62mm
U12: 74LS377; DIP-20_W7.62mm
U13, U14: 16550; DIP-40_W15.24mm
U16: 4040; DIP-16_W7.62mm
U17, U19, U21, U35: 74HC04; DIP-14_W7.62mm
U18: 74LS173; DIP-16_W7.62mm
U20: 74LS244; DIP-20_W7.62mm
U22: 74HCT244; DIP-20_W7.62mm
U_ROM1, U_ROM2, U_ROM3, U_ROM4, U_ROM5, U_ROM6, U_ROM7, U_ROM8, U_ROM9, U_ROM10, U_ROM11, U_ROM12, U_ROM13, U_ROM14, U_ROM15: 27512; DIP-28_W15.24mm
WD1: DIP-28_W15.24mm
X1: ACO-10MHz; Oscillator_DIP-14
X2: 8mhz_osc; Oscillator_DIP-14
esp8266: (no value)

Connections (part):
/ah0: IC55.2 (1Q), IC123.3 (D1)
/ah1: IC55.5 (2Q), IC127.3 (D1)
/ah2: IC55.6 (3Q), IC131.3 (D1)
/ah3: IC55.9 (4Q), IC135.3 (D1)
/ah4: IC55.12 (5Q), IC139.3 (D1)
/ah5: IC55.15 (6Q), IC143.3 (D1)
/ah6: IC55.16 (7Q), IC147.3 (D1)
/ah7: IC55.19 (8Q), IC151.3 (D1)
/al0: IC54.2 (1Q), IC123.4 (D0)
/al1: IC54.5 (2Q), IC127.4 (D0)
/al2: IC54.6 (3Q), IC131.4 (D0)
/al3: IC54.9 (4Q), IC135.4 (D0)
/al4: IC54.12 (5Q), IC139.4 (D0)
/al5: IC54.15 (6Q), IC143.4 (D0)
/al6: IC54.16 (7Q), IC147.4 (D0)
/al7: IC54.19 (8Q), IC151.4 (D0)
/alu_cf: ALU_HIGH1.16 (CN+4), IC_86_1.5 (I1)
/alu_final_cf: IC18.5 (1C1), IC88.3 (D1), IC_86_1.6 (O)
/alu_of: IC20.3 (1B), IC90.3 (D1), IC_04_1.4 (O)
/alu_output_0: ALU_LOW1.9 (F0), IC18.4 (1C2), IC28.1 (D3), IC31.6 (1C0), IC31.12 (2C2), IC88.2 (D2)
/alu_output_1: ALU_LOW1.10 (F1), IC31.5 (1C1), IC31.10 (2C0), IC32.4 (1C2)
/alu_output_2: ALU_LOW1.11 (F2), IC31.11 (2C1), IC32.6 (1C0), IC32.12 (2C2)
/alu_output_3: ALU_LOW1.13 (F3), IC32.5 (1C1), IC32.10 (2C0), IC33.4 (1C2)
/alu_output_4: ALU_HIGH1.9 (F0), IC32.11 (2C1), IC33.6 (1C0), IC33.12 (2C2)
/alu_output_5: ALU_HIGH1.10 (F1), IC33.5 (1C1), IC33.10 (2C0), IC34.4 (1C2)
/alu_output_6: ALU_HIGH1.11 (F2), IC33.11 (2C1), IC34.6 (1C0), IC34.12 (2C2)
/alu_output_7: ALU_HIGH1.13 (F3), IC18.3 (1C3), IC28.15 (D4), IC31.3 (1C3), IC31.13 (2C3), IC32.3 (1C3), IC32.13 (2C3), IC33.3 (1C3), IC33.13 (2C3), IC34.3 (1C3), IC34.5 (1C1), IC34.10 (2C0), IC34.13 (2C3), IC88.15 (D4)
/alu_zf: IC13.1 (I0), IC17.5 (1C1), IC75.3 (I0), IC75.12 (O), IC87.5 (1C1)
/any_interruption: IC13.10 (I1), IC29.6 (O)
/bh0: IC57.2 (1Q), IC123.1 (D3)
/bh1: IC57.5 (2Q), IC127.1 (D3)
/bh2: IC57.6 (3Q), IC131.1 (D3)
/bh3: IC57.9 (4Q), IC135.1 (D3)
/bh4: IC57.12 (5Q), IC139.1 (D3)
/bh5: IC57.15 (6Q), IC143.1 (D3)
/bh6: IC57.16 (7Q), IC147.1 (D3)
/bh7: IC57.19 (8Q), IC151.1 (D3)
/bl0: IC56.2 (1Q), IC123.2 (D2)
/bl1: IC56.5 (2Q), IC127.2 (D2)
/bl2: IC56.6 (3Q), IC131.2 (D2)
/bl3: IC56.9 (4Q), IC135.2 (D2)
/bl4: IC56.12 (5Q), IC139.2 (D2)
/bl5: IC56.15 (6Q), IC143.2 (D2)
/bl6: IC56.16 (7Q), IC147.2 (D2)
/bl7: IC56.19 (8Q), IC151.2 (D2)
/bph0: IC67.2 (1Q), IC124.1 (D3)
/bph1: IC67.5 (2Q), IC128.1 (D3)
/bph2: IC67.6 (3Q), IC132.1 (D3)
/bph3: IC67.9 (4Q), IC136.1 (D3)
/bph4: IC67.12 (5Q), IC140.1 (D3)
/bph5: IC67.15 (6Q), IC144.1 (D3)
/bph6: IC67.16 (7Q), IC148.1 (D3)
/bph7: IC67.19 (8Q), IC152.1 (D3)
/bpl0: IC66.2 (1Q), IC124.2 (D2)
/bpl1: IC66.5 (2Q), IC128.2 (D2)
/bpl2: IC66.6 (3Q), IC132.2 (D2)
/bpl3: IC66.9 (4Q), IC136.2 (D2)
/bpl4: IC66.12 (5Q), IC140.2 (D2)
/bpl5: IC66.15 (6Q), IC144.2 (D2)
/bpl6: IC66.16 (7Q), IC148.2 (D2)
/bpl7: IC66.19 (8Q), IC152.2 (D2)
/buffered_mem_io: IC113.5 (I), IC122.1 (I0), IC176.4 (G2A), IC176.5 (G2B), IC197.14 (Y3), IC_10_2.11 (I2)
/buffered_rd_memory: IC197.12 (Y4), U1.24 (OE), U2.24 (OE), U3.24 (OE), U4.24 (OE), U5.24 (OE), U6.24 (OE), U7.24 (OE), U8.24 (OE)
/buffered_wr_memory: IC197.9 (Y1), U1.29 (WE), U2.29 (WE), U3.29 (WE), U4.29 (WE), U5.29 (WE), U6.29 (WE), U7.29 (WE), U8.29 (WE)
/bus_rd: IC186.18 (Y1), IC196.18 (Y1), IC197.2 (A1), IC197.8 (A4)
/bus_tristate: IC109.1 (I0), IC117.1 (G), IC117.19 (G), IC118.1 (G), IC118.19 (G), IC119.1 (G), IC119.19 (G), IC120.1 (G), IC155.1 (~A/B), IC156.1 (~A/B), IC192.6 (O), IC194.9 (I), IC196.1 (G)
/bus_wr: IC186.16 (Y2), IC196.16 (Y2), IC197.4 (A2), IC197.11 (A1)
/ch0: IC59.2 (1Q), IC123.14 (D5)
/ch1: IC59.5 (2Q), IC127.14 (D5)
/ch2: IC59.6 (3Q), IC131.14 (D5)
/ch3: IC59.9 (4Q), IC135.14 (D5)
/ch4: IC59.12 (5Q), IC139.14 (D5)
/ch5: IC59.15 (6Q), IC143.14 (D5)
/ch6: IC59.16 (7Q), IC147.14 (D5)
/ch7: IC59.19 (8Q), IC151.14 (D5)
/cl0: IC58.2 (1Q), IC123.15 (D4)
/cl1: IC58.5 (2Q), IC127.15 (D4)
/cl2: IC58.6 (3Q), IC131.15 (D4)
/cl3: IC58.9 (4Q), IC135.15 (D4)
/cl4: IC58.12 (5Q), IC139.15 (D4)
/cl5: IC58.15 (6Q), IC143.15 (D4)
/cl6: IC58.16 (7Q), IC147.15 (D4)
/cl7: IC58.19 (8Q), IC151.15 (D4)
/clk_crystal: SW5.2, U18.14 (D0), U35.6
/condition: IC37.2 (I1), IC76.4 (1Y)
/dh0: IC61.2 (1Q), IC123.12 (D7)
/dh1: IC61.5 (2Q), IC127.12 (D7)
/dh2: IC61.6 (3Q), IC131.12 (D7)
/dh3: IC61.9 (4Q), IC135.12 (D7)
/dh4: IC61.12 (5Q), IC139.12 (D7)
/dh5: IC61.15 (6Q), IC143.12 (D7)
/dh6: IC61.16 (7Q), IC147.12 (D7)
/dh7: IC61.19 (8Q), IC151.12 (D7)
/dih0: IC71.2 (1Q), IC124.12 (D7)
/dih1: IC71.5 (2Q), IC128.12 (D7)
/dih2: IC71.6 (3Q), IC132.12 (D7)
/dih3: IC71.9 (4Q), IC136.12 (D7)
/dih4: IC71.12 (5Q), IC140.12 (D7)
/dih5: IC71.15 (6Q), IC144.12 (D7)
/dih6: IC71.16 (7Q), IC148.12 (D7)
/dih7: IC71.19 (8Q), IC152.12 (D7)
/dil0: IC70.2 (1Q), IC124.13 (D6)
/dil1: IC70.5 (2Q), IC128.13 (D6)
/dil2: IC70.6 (3Q), IC132.13 (D6)
/dil3: IC70.9 (4Q), IC136.13 (D6)
/dil4: IC70.12 (5Q), IC140.13 (D6)
/dil5: IC70.15 (6Q), IC144.13 (D6)
/dil6: IC70.16 (7Q), IC148.13 (D6)
/dil7: IC70.19 (8Q), IC152.13 (D6)
/dl0: IC60.2 (1Q), IC123.13 (D6)
/dl1: IC60.5 (2Q), IC127.13 (D6)
/dl2: IC60.6 (3Q), IC131.13 (D6)
/dl3: IC60.9 (4Q), IC135.13 (D6)
/dl4: IC60.12 (5Q), IC139.13 (D6)
/dl5: IC60.15 (6Q), IC143.13 (D6)
/dl6: IC60.16 (7Q), IC147.13 (D6)
/dl7: IC60.19 (8Q), IC151.13 (D6)
/ext_input: IC50.1 (D3), IC164.9 (Q)
/final_condition: IC21.3 (I), IC37.3 (O)
/flags_4: FLAGS1.12 (Q5), IC5.6 (1C0), IC93.2 (1A)
/flags_5: FLAGS1.15 (Q6), IC5.10 (2C0), IC93.5 (2A)
/flags_6: FLAGS1.16 (Q7), IC6.6 (1C0), IC93.11 (3A)
/flags_7: FLAGS1.19 (Q8), IC6.10 (2C0), IC93.14 (4A)
/flags_cf: FLAGS1.5 (Q2), IC3.10 (2C0), IC14.5 (1C1), IC28.2 (D2), IC30.5 (2A), IC88.4 (D0)
/flags_of: FLAGS1.9 (Q4), IC4.10 (2C0), IC30.14 (4A), IC90.4 (D0)
/flags_sf: FLAGS1.6 (Q3), IC4.6 (1C0), IC30.11 (3A), IC89.6 (1C0)
/flags_zf: FLAGS1.2 (Q1), IC3.6 (1C0), IC30.2 (1A), IC75.5 (I2), IC87.6 (1C0)
/int_pending: IC29.2 (I1), IC35.3 (O), IC50.2 (D2)
/int_request: IC35.1 (I0), IRQ_ENCODER1.15 (EO)
/int_status_0: IC46.2 (I1), IC126.15 (D4), IRQ_STATUS_1.2 (Q1); also elsewhere on the board
/int_status_1: IC46.5 (I1), IC130.15 (D4), IRQ_STATUS_1.5 (Q2); also elsewhere on the board
/int_status_2: IC46.10 (I1), IC134.15 (D4), IRQ_STATUS_1.6 (Q3); also elsewhere on the board
/int_status_3: IC46.13 (I1), IC138.15 (D4), IRQ_STATUS_1.9 (Q4); also elsewhere on the board
/int_status_4: IC52.2 (I1), IC142.15 (D4), IRQ_STATUS_1.12 (Q5); also elsewhere on the board
/int_status_5: IC52.5 (I1), IC146.15 (D4), IRQ_STATUS_1.15 (Q6); also elsewhere on the board
/int_status_6: IC52.10 (I1), IC150.15 (D4), IRQ_STATUS_1.16 (Q7); also elsewhere on the board
/int_status_7: IC52.13 (I1), IC154.15 (D4), IRQ_STATUS_1.19 (Q8); also elsewhere on the board
/ir0: IC42.2 (1Q), IC80.5 (1C1)
/ir1: IC42.5 (2Q), IC80.11 (2C1)
/ir2: IC42.6 (3Q), IC81.5 (1C1)
/ir3: IC42.9 (4Q), IC81.11 (2C1)
/ir4: IC42.12 (5Q), IC82.5 (1C1)
/ir5: IC42.15 (6Q), IC82.11 (2C1)
/ir6: IC42.16 (7Q), IC83.5 (1C1)
/ir7: IC42.19 (8Q), IC83.11 (2C1)
/irq_masks0: IC46.1 (I0), IC74.2 (1Q), IC126.1 (D3); also elsewhere on the board
/irq_masks1: IC46.4 (I0), IC74.5 (2Q), IC130.1 (D3); also elsewhere on the board
/irq_masks2: IC46.9 (I0), IC74.6 (3Q), IC134.1 (D3); also elsewhere on the board
/irq_masks3: IC46.12 (I0), IC74.9 (4Q), IC138.1 (D3); also elsewhere on the board
/irq_masks4: IC52.1 (I0), IC74.12 (5Q), IC142.1 (D3); also elsewhere on the board
/irq_masks5: IC52.4 (I0), IC74.15 (6Q), IC146.1 (D3); also elsewhere on the board
/irq_masks6: IC52.9 (I0), IC74.16 (7Q), IC150.1 (D3); also elsewhere on the board
/irq_masks7: IC52.12 (I0), IC74.19 (8Q), IC154.1 (D3); also elsewhere on the board
/irq_vector_0: IC126.2 (D2), IRQ_CODE1.2 (1Q)
/irq_vector_1: IC130.2 (D2), IRQ_CODE1.5 (2Q), IRQ_RST_DECODER1.1 (A)
/irq_vector_2: IC134.2 (D2), IRQ_CODE1.6 (3Q), IRQ_RST_DECODER1.2 (B)
/irq_vector_3: IC138.2 (D2), IRQ_CODE1.9 (4Q), IRQ_RST_DECODER1.3 (C)
/irq_vector_4: IC142.2 (D2), IRQ_CODE1.12 (5Q)
/irq_vector_5: IC146.2 (D2), IRQ_CODE1.15 (6Q)
/irq_vector_6: IC150.2 (D2), IRQ_CODE1.16 (7Q)
/irq_vector_7: IC154.2 (D2), IRQ_CODE1.19 (8Q)
/kbus0: IC7.7 (1Y), IC15.3 (1B)
/kbus1: IC7.9 (2Y), IC15.6 (2B)
/kbus2: IC8.7 (1Y), IC15.10 (3B)
/kbus3: IC8.9 (2Y), IC15.13 (4B)
/kbus4: IC9.7 (1Y), IC16.3 (1B)
/kbus5: IC9.9 (2Y), IC16.6 (2B)
/kbus6: IC10.7 (1Y), IC16.10 (3B)
/kbus7: IC10.9 (2Y), IC16.13 (4B)
/ksph0: IC85.2 (1Q), IC126.3 (D1)
/ksph1: IC85.5 (2Q), IC130.3 (D1)
/ksph2: IC85.6 (3Q), IC134.3 (D1)
/ksph3: IC85.9 (4Q), IC138.3 (D1)
/ksph4: IC85.12 (5Q), IC142.3 (D1)
/ksph5: IC85.15 (6Q), IC146.3 (D1)
/ksph6: IC85.16 (7Q), IC150.3 (D1)
/ksph7: IC85.19 (8Q), IC154.3 (D1)
/kspl0: IC84.2 (1Q), IC126.4 (D0)
/kspl1: IC84.5 (2Q), IC130.4 (D0)
/kspl2: IC84.6 (3Q), IC134.4 (D0)
/kspl3: IC84.9 (4Q), IC138.4 (D0)
/kspl4: IC84.12 (5Q), IC142.4 (D0)
/kspl5: IC84.15 (6Q), IC146.4 (D0)
/kspl6: IC84.16 (7Q), IC150.4 (D0)
/kspl7: IC84.19 (8Q), IC154.4 (D0)
/marh_0: IC118.2 (A1), IC125.1 (D3), MARH1.2 (1Q)
/marh_1: IC118.4 (A2), IC129.1 (D3), MARH1.5 (2Q)
/marh_2: IC118.6 (A3), IC133.1 (D3), MARH1.6 (3Q)
/marh_3: IC137.1 (D3), IC157.2 (1A), MARH1.9 (4Q), PAGE_TABLE_RAM_0.10 (A0), PAGE_TABLE_RAM_1.10 (A0)
/marh_4: IC141.1 (D3), IC157.5 (2A), MARH1.12 (5Q), PAGE_TABLE_RAM_0.9 (A1), PAGE_TABLE_RAM_1.9 (A1)
/marh_5: IC145.1 (D3), IC157.11 (3A), MARH1.15 (6Q), PAGE_TABLE_RAM_0.8 (A2), PAGE_TABLE_RAM_1.8 (A2)
/marh_6: IC149.1 (D3), IC157.14 (4A), MARH1.16 (7Q), PAGE_TABLE_RAM_0.7 (A3), PAGE_TABLE_RAM_1.7 (A3)
/marh_7: IC153.1 (D3), IC158.2 (1A), MARH1.19 (8Q), PAGE_TABLE_RAM_0.6 (A4), PAGE_TABLE_RAM_1.6 (A4)
/marl_0: IC117.2 (A1), IC125.2 (D2), MARL1.2 (1Q)
/marl_1: IC117.4 (A2), IC129.2 (D2), MARL1.5 (2Q)
/marl_2: IC117.6 (A3), IC133.2 (D2), MARL1.6 (3Q)
/marl_3: IC117.8 (A4), IC137.2 (D2), MARL1.9 (4Q)
/marl_4: IC117.11 (A1), IC141.2 (D2), MARL1.12 (5Q)
/marl_5: IC117.13 (A2), IC145.2 (D2), MARL1.15 (6Q)
/marl_6: IC117.15 (A3), IC149.2 (D2), MARL1.16 (7Q)
/marl_7: IC117.17 (A4), IC153.2 (D2), MARL1.19 (8Q)
/mdrh_0: IC7.5 (1C1), IC125.14 (D5), IC180.2 (A1), MDRH1.2 (1Q), MDR_OUT_MUX_1.3 (1B)
/mdrh_1: IC7.11 (2C1), IC129.14 (D5), IC180.4 (A2), MDRH1.5 (2Q), MDR_OUT_MUX_1.6 (2B)
/mdrh_2: IC8.5 (1C1), IC133.14 (D5), IC180.6 (A3), MDRH1.6 (3Q), MDR_OUT_MUX_1.10 (3B)
/mdrh_3: IC8.11 (2C1), IC137.14 (D5), IC180.8 (A4), MDRH1.9 (4Q), MDR_OUT_MUX_1.13 (4B)
/mdrh_4: IC9.5 (1C1), IC141.14 (D5), IC180.11 (A1), MDRH1.12 (5Q), MDR_OUT_MUX_2.3 (1B)
/mdrh_5: IC9.11 (2C1), IC145.14 (D5), IC180.13 (A2), MDRH1.15 (6Q), MDR_OUT_MUX_2.6 (2B)
/mdrh_6: IC10.5 (1C1), IC149.14 (D5), IC180.15 (A3), MDRH1.16 (7Q), MDR_OUT_MUX_2.10 (3B)
/mdrh_7: IC10.11 (2C1), IC153.14 (D5), IC180.17 (A4), MDRH1.19 (8Q), MDR_OUT_MUX_2.13 (4B)
/mdrl_0: IC7.6 (1C0), IC125.15 (D4), IC179.2 (A1), MDRL1.2 (1Q), MDR_OUT_MUX_1.2 (1A)
/mdrl_1: IC7.10 (2C0), IC129.15 (D4), IC179.4 (A2), MDRL1.5 (2Q), MDR_OUT_MUX_1.5 (2A)
/mdrl_2: IC8.6 (1C0), IC133.15 (D4), IC179.6 (A3), MDRL1.6 (3Q), MDR_OUT_MUX_1.11 (3A)
/mdrl_3: IC8.10 (2C0), IC137.15 (D4), IC179.8 (A4), MDRL1.9 (4Q), MDR_OUT_MUX_1.14 (4A)
/mdrl_4: IC9.6 (1C0), IC141.15 (D4), IC179.11 (A1), MDRL1.12 (5Q), MDR_OUT_MUX_2.2 (1A)
/mdrl_5: IC9.10 (2C0), IC145.15 (D4), IC179.13 (A2), MDRL1.15 (6Q), MDR_OUT_MUX_2.5 (2A)
/mdrl_6: IC10.6 (1C0), IC149.15 (D4), IC179.15 (A3), MDRL1.16 (7Q), MDR_OUT_MUX_2.11 (3A)
/mdrl_7: IC10.10 (2C0), IC153.15 (D4), IC179.17 (A4), MDRL1.19 (8Q), MDR_OUT_MUX_2.14 (4A)
/mem_select_0: IC176.15 (Y0), U7.22 (CE)
/mem_select_1: IC176.14 (Y1), U6.22 (CE)
/mem_select_2: IC176.13 (Y2), U5.22 (CE)
/mem_select_3: IC176.12 (Y3), U4.22 (CE)
/mem_select_4: IC176.11 (Y4), U8.22 (CE)
/mem_select_5: IC176.10 (Y5), U3.22 (CE)
/mem_select_6: IC176.9 (Y6), U2.22 (CE)
/mem_select_7: IC176.7 (Y7), U1.22 (CE)
/mux_a: IC13.11 (O), IC77.14 (A), IC78.14 (A), IC79.14 (A), IC80.14 (A), IC81.14 (A), IC82.14 (A), IC83.14 (A)
/mux_b: IC13.6 (O), IC77.2 (B), IC78.2 (B), IC79.2 (B), IC80.2 (B), IC81.2 (B), IC82.2 (B), IC83.2 (B)
/page_table_addr_source: IC29.8 (O), IC190.1 (~A/B), IC191.1 (~A/B)
/panel_address_0: IC198.2 (A1), RN4.1 (R1.1), SW7.8
/panel_address_1: IC198.4 (A2), RN4.2 (R2.1), SW7.7
/panel_address_2: IC198.6 (A3), RN4.3 (R3.1), SW7.6
/panel_address_3: IC198.8 (A4), RN4.4 (R4.1), SW7.5
/panel_address_4: IC198.11 (A1), RN4.5 (R5.1), SW7.4
/panel_address_5: IC198.13 (A2), RN4.6 (R6.1), SW7.3
/panel_address_6: IC198.15 (A3), RN4.7 (R7.1), SW7.2
/panel_address_7: IC198.17 (A4), RN4.8 (R8.1), SW7.1
/panel_address_8: IC200.2 (A1), RN3.1 (R1.1), SW6.8
/panel_address_9: IC200.4 (A2), RN3.2 (R2.1), SW6.7
/panel_address_10: IC200.6 (A3), RN3.3 (R3.1), SW6.6
/panel_address_11: IC200.8 (A4), RN3.4 (R4.1), SW6.5
/panel_address_12: IC200.11 (A1), RN3.5 (R5.1), SW6.4
/panel_address_13: IC200.13 (A2), RN3.6 (R6.1), SW6.3
/panel_address_14: IC200.15 (A3), RN3.7 (R7.1), SW6.2
/panel_address_15: IC200.17 (A4), RN3.8 (R8.1), SW6.1
/panel_address_16: IC202.2 (A1), RN5.1 (R1.1), SW8.8
/panel_address_17: IC202.4 (A2), RN5.2 (R2.1), SW8.7
/panel_address_18: IC202.6 (A3), RN5.3 (R3.1), SW8.6
/panel_address_19: IC202.8 (A4), RN5.4 (R4.1), SW8.5
/panel_address_20: IC202.11 (A1), RN5.5 (R5.1), SW8.4
/panel_address_21: IC202.13 (A2), RN5.6 (R6.1), SW8.3
/panel_data_0: IC204.11 (A1), RN6.1 (R1.1), SW9.8
/panel_data_1: IC204.13 (A2), RN6.2 (R2.1), SW9.7
/panel_data_2: IC204.15 (A3), RN6.3 (R3.1), SW9.6
/panel_data_3: IC204.17 (A4), RN6.4 (R4.1), SW9.5
/panel_data_4: IC206.2 (A1), RN6.5 (R5.1), SW9.4
/panel_data_5: IC206.4 (A2), RN6.6 (R6.1), SW9.3
/panel_data_6: IC206.6 (A3), RN6.7 (R7.1), SW9.2
/panel_data_7: IC206.8 (A4), RN6.8 (R8.1), SW9.1
/pch0: IC63.2 (1Q), IC125.3 (D1), IC183.3 (1B)
/pch1: IC63.5 (2Q), IC129.3 (D1), IC183.6 (2B)
/pch2: IC63.6 (3Q), IC133.3 (D1), IC183.10 (3B)
/pch3: IC63.9 (4Q), IC137.3 (D1), IC183.13 (4B)
/pch4: IC63.12 (5Q), IC141.3 (D1), IC184.3 (1B)
/pch5: IC63.15 (6Q), IC145.3 (D1), IC184.6 (2B)
/pch6: IC63.16 (7Q), IC149.3 (D1), IC184.10 (3B)
/pch7: IC63.19 (8Q), IC153.3 (D1), IC184.13 (4B)
/pcl0: IC62.2 (1Q), IC125.4 (D0), IC181.3 (1B)
/pcl1: IC62.5 (2Q), IC129.4 (D0), IC181.6 (2B)
/pcl2: IC62.6 (3Q), IC133.4 (D0), IC181.10 (3B)
/pcl3: IC62.9 (4Q), IC137.4 (D0), IC181.13 (4B)
/pcl4: IC62.12 (5Q), IC141.4 (D0), IC182.3 (1B)
/pcl5: IC62.15 (6Q), IC145.4 (D0), IC182.6 (2B)
/pcl6: IC62.16 (7Q), IC149.4 (D0), IC182.10 (3B)
/pcl7: IC62.19 (8Q), IC153.4 (D0), IC182.13 (4B)
/sih0: IC69.2 (1Q), IC124.14 (D5)
/sih1: IC69.5 (2Q), IC128.14 (D5)
/sih2: IC69.6 (3Q), IC132.14 (D5)
/sih3: IC69.9 (4Q), IC136.14 (D5)
/sih4: IC69.12 (5Q), IC140.14 (D5)
/sih5: IC69.15 (6Q), IC144.14 (D5)
/sih6: IC69.16 (7Q), IC148.14 (D5)
/sih7: IC69.19 (8Q), IC152.14 (D5)
/sil0: IC68.2 (1Q), IC124.15 (D4)
/sil1: IC68.5 (2Q), IC128.15 (D4)
/sil2: IC68.6 (3Q), IC132.15 (D4)
/sil3: IC68.9 (4Q), IC136.15 (D4)
/sil4: IC68.12 (5Q), IC140.15 (D4)
/sil5: IC68.15 (6Q), IC144.15 (D4)
/sil6: IC68.16 (7Q), IC148.15 (D4)
/sil7: IC68.19 (8Q), IC152.15 (D4)
/single_step_clk: IC175.4 (Q), SW5.1
/sph0: IC65.2 (1Q), IC124.3 (D1)
/sph1: IC65.5 (2Q), IC128.3 (D1)
/sph2: IC65.6 (3Q), IC132.3 (D1)
/sph3: IC65.9 (4Q), IC136.3 (D1)
/sph4: IC65.12 (5Q), IC140.3 (D1)
/sph5: IC65.15 (6Q), IC144.3 (D1)
/sph6: IC65.16 (7Q), IC148.3 (D1)
/sph7: IC65.19 (8Q), IC152.3 (D1)
/spl0: IC64.2 (1Q), IC124.4 (D0)
/spl1: IC64.5 (2Q), IC128.4 (D0)
/spl2: IC64.6 (3Q), IC132.4 (D0)
/spl3: IC64.9 (4Q), IC136.4 (D0)
/spl4: IC64.12 (5Q), IC140.4 (D0)
/spl5: IC64.15 (6Q), IC144.4 (D0)
/spl6: IC64.16 (7Q), IC148.4 (D0)
/spl7: IC64.19 (8Q), IC152.4 (D0)
/status_6: IC6.5 (1C1), IC36.16 (7Q)
/status_cpu_mode: IC4.5 (1C1), IC29.10 (I1), IC36.6 (3Q), IC50.4 (D0), IC53.1 (I0), IC53.4 (I0)
/status_dir: IC6.11 (2C1), IC36.19 (8Q), IC50.15 (D4)
/status_display_reg_load: IC5.11 (2C1), IC36.15 (6Q), IC50.14 (D5)
/status_dma_ack: IC3.5 (1C1), IC36.2 (1Q), IC192.4 (I0)
/status_halt: IC5.5 (1C1), IC36.12 (5Q), IC192.5 (I1)
/status_irq_enable: IC3.11 (2C1), IC35.2 (I1), IC36.5 (2Q)
/status_paging_en: IC4.11 (2C1), IC36.9 (4Q), IC157.1 (~A/B), IC158.1 (~A/B), IC159.1 (~A/B), IC160.1 (~A/B)
/stop_clk_req: IC170.2 (D), RN8.7 (R7.1), SW11.2 (B)
/stop_clock: IC170.5 (Q), U18.9 (E1), U18.10 (E2)
/tdrh0: IC7.3 (1C3), IC73.2 (1Q), IC125.12 (D7)
/tdrh1: IC7.13 (2C3), IC73.5 (2Q), IC129.12 (D7)
/tdrh2: IC8.3 (1C3), IC73.6 (3Q), IC133.12 (D7)
/tdrh3: IC8.13 (2C3), IC73.9 (4Q), IC137.12 (D7)
/tdrh4: IC9.3 (1C3), IC73.12 (5Q), IC141.12 (D7)
/tdrh5: IC9.13 (2C3), IC73.15 (6Q), IC145.12 (D7)
/tdrh6: IC10.3 (1C3), IC73.16 (7Q), IC149.12 (D7)
/tdrh7: IC10.13 (2C3), IC73.19 (8Q), IC153.12 (D7)
/tdrl0: IC7.4 (1C2), IC72.2 (1Q), IC125.13 (D6)
/tdrl1: IC7.12 (2C2), IC72.5 (2Q), IC129.13 (D6)
/tdrl2: IC8.4 (1C2), IC72.6 (3Q), IC133.13 (D6)
/tdrl3: IC8.12 (2C2), IC72.9 (4Q), IC137.13 (D6)
/tdrl4: IC9.4 (1C2), IC72.12 (5Q), IC141.13 (D6)
/tdrl5: IC9.12 (2C2), IC72.15 (6Q), IC145.13 (D6)
/tdrl6: IC10.4 (1C2), IC72.16 (7Q), IC149.13 (D6)
/tdrl7: IC10.12 (2C2), IC72.19 (8Q), IC153.13 (D6)
/u_ad0: IC38.5 (A1), IC91.2 (Q1), U_ROM1.10 (A0), U_ROM2.10 (A0), U_ROM3.10 (A0), U_ROM4.10 (A0), U_ROM5.10 (A0), U_ROM6.10 (A0), U_ROM7.10 (A0), U_ROM8.10 (A0), U_ROM9.10 (A0), U_ROM10.10 (A0), U_ROM11.10 (A0), U_ROM12.10 (A0), U_ROM13.10 (A0), U_ROM14.10 (A0), U_ROM15.10 (A0)
/u_ad1: IC38.3 (A2), IC91.5 (Q2), U_ROM1.9 (A1), U_ROM2.9 (A1), U_ROM3.9 (A1), U_ROM4.9 (A1), U_ROM5.9 (A1), U_ROM6.9 (A1), U_ROM7.9 (A1), U_ROM8.9 (A1), U_ROM9.9 (A1), U_ROM10.9 (A1), U_ROM11.9 (A1), U_ROM12.9 (A1), U_ROM13.9 (A1), U_ROM14.9 (A1), U_ROM15.9 (A1)
/u_ad2: IC38.14 (A3), IC91.6 (Q3), U_ROM1.8 (A2), U_ROM2.8 (A2), U_ROM3.8 (A2), U_ROM4.8 (A2), U_ROM5.8 (A2), U_ROM6.8 (A2), U_ROM7.8 (A2), U_ROM8.8 (A2), U_ROM9.8 (A2), U_ROM10.8 (A2), U_ROM11.8 (A2), U_ROM12.8 (A2), U_ROM13.8 (A2), U_ROM14.8 (A2), U_ROM15.8 (A2)
/u_ad3: IC38.12 (A4), IC91.9 (Q4), U_ROM1.7 (A3), U_ROM2.7 (A3), U_ROM3.7 (A3), U_ROM4.7 (A3), U_ROM5.7 (A3), U_ROM6.7 (A3), U_ROM7.7 (A3), U_ROM8.7 (A3), U_ROM9.7 (A3), U_ROM10.7 (A3), U_ROM11.7 (A3), U_ROM12.7 (A3), U_ROM13.7 (A3), U_ROM14.7 (A3), U_ROM15.7 (A3)
/u_ad4: IC39.5 (A1), IC91.12 (Q5), U_ROM1.6 (A4), U_ROM2.6 (A4), U_ROM3.6 (A4), U_ROM4.6 (A4), U_ROM5.6 (A4), U_ROM6.6 (A4), U_ROM7.6 (A4), U_ROM8.6 (A4), U_ROM9.6 (A4), U_ROM10.6 (A4), U_ROM11.6 (A4), U_ROM12.6 (A4), U_ROM13.6 (A4), U_ROM14.6 (A4), U_ROM15.6 (A4)
/u_ad5: IC39.3 (A2), IC91.15 (Q6), U_ROM1.5 (A5), U_ROM2.5 (A5), U_ROM3.5 (A5), U_ROM4.5 (A5), U_ROM5.5 (A5), U_ROM6.5 (A5), U_ROM7.5 (A5), U_ROM8.5 (A5), U_ROM9.5 (A5), U_ROM10.5 (A5), U_ROM11.5 (A5), U_ROM12.5 (A5), U_ROM13.5 (A5), U_ROM14.5 (A5), U_ROM15.5 (A5)
/u_ad6: IC39.14 (A3), IC91.16 (Q7), U_ROM1.4 (A6), U_ROM2.4 (A6), U_ROM3.4 (A6), U_ROM4.4 (A6), U_ROM5.4 (A6), U_ROM6.4 (A6), U_ROM7.4 (A6), U_ROM8.4 (A6), U_ROM9.4 (A6), U_ROM10.4 (A6), U_ROM11.4 (A6), U_ROM12.4 (A6), U_ROM13.4 (A6), U_ROM14.4 (A6), U_ROM15.4 (A6)
/u_ad7: IC39.12 (A4), IC91.19 (Q8), U_ROM1.3 (A7), U_ROM2.3 (A7), U_ROM3.3 (A7), U_ROM4.3 (A7), U_ROM5.3 (A7), U_ROM6.3 (A7), U_ROM7.3 (A7), U_ROM8.3 (A7), U_ROM9.3 (A7), U_ROM10.3 (A7), U_ROM11.3 (A7), U_ROM12.3 (A7), U_ROM13.3 (A7), U_ROM14.3 (A7), U_ROM15.3 (A7)
/u_ad8: IC40.5 (A1), IC92.2 (Q1), U_ROM1.25 (A8), U_ROM2.25 (A8), U_ROM3.25 (A8), U_ROM4.25 (A8), U_ROM5.25 (A8), U_ROM6.25 (A8), U_ROM7.25 (A8), U_ROM8.25 (A8), U_ROM9.25 (A8), U_ROM10.25 (A8), U_ROM11.25 (A8), U_ROM12.25 (A8), U_ROM13.25 (A8), U_ROM14.25 (A8), U_ROM15.25 (A8)
/u_ad9: IC40.3 (A2), IC92.5 (Q2), U_ROM1.24 (A9), U_ROM2.24 (A9), U_ROM3.24 (A9), U_ROM4.24 (A9), U_ROM5.24 (A9), U_ROM6.24 (A9), U_ROM7.24 (A9), U_ROM8.24 (A9), U_ROM9.24 (A9), U_ROM10.24 (A9), U_ROM11.24 (A9), U_ROM12.24 (A9), U_ROM13.24 (A9), U_ROM14.24 (A9), U_ROM15.24 (A9)
/u_ad10: IC40.14 (A3), IC92.6 (Q3), U_ROM1.21 (A10), U_ROM2.21 (A10), U_ROM3.21 (A10), U_ROM4.21 (A10), U_ROM5.21 (A10), U_ROM6.21 (A10), U_ROM7.21 (A10), U_ROM8.21 (A10), U_ROM9.21 (A10), U_ROM10.21 (A10), U_ROM11.21 (A10), U_ROM12.21 (A10), U_ROM13.21 (A10), U_ROM14.21 (A10), U_ROM15.21 (A10)
/u_ad11: IC40.12 (A4), IC92.9 (Q4), U_ROM1.23 (A11), U_ROM2.23 (A11), U_ROM3.23 (A11), U_ROM4.23 (A11), U_ROM5.23 (A11), U_ROM6.23 (A11), U_ROM7.23 (A11), U_ROM8.23 (A11), U_ROM9.23 (A11), U_ROM10.23 (A11), U_ROM11.23 (A11), U_ROM12.23 (A11), U_ROM13.23 (A11), U_ROM14.23 (A11), U_ROM15.23 (A11)
/u_ad12: IC41.5 (A1), IC92.12 (Q5), U_ROM1.2 (A12), U_ROM2.2 (A12), U_ROM3.2 (A12), U_ROM4.2 (A12), U_ROM5.2 (A12), U_ROM6.2 (A12), U_ROM7.2 (A12), U_ROM8.2 (A12), U_ROM9.2 (A12), U_ROM10.2 (A12), U_ROM11.2 (A12), U_ROM12.2 (A12), U_ROM13.2 (A12), U_ROM14.2 (A12), U_ROM15.2 (A12)
/u_ad13: IC41.3 (A2), IC92.15 (Q6), U_ROM1.26 (A13), U_ROM2.26 (A13), U_ROM3.26 (A13), U_ROM4.26 (A13), U_ROM5.26 (A13), U_ROM6.26 (A13), U_ROM7.26 (A13), U_ROM8.26 (A13), U_ROM9.26 (A13), U_ROM10.26 (A13), U_ROM11.26 (A13), U_ROM12.26 (A13), U_ROM13.26 (A13), U_ROM14.26 (A13), U_ROM15.26 (A13)
/u_adder0: IC38.4 (S1), IC77.6 (1C0)
/u_adder1: IC38.1 (S2), IC77.10 (2C0)
/u_adder2: IC38.13 (S3), IC78.6 (1C0)
/u_adder3: IC38.10 (S4), IC78.10 (2C0)
/u_adder4: IC39.4 (S1), IC79.6 (1C0)
/u_adder5: IC39.1 (S2), IC79.10 (2C0)
/u_adder6: IC39.13 (S3), IC80.6 (1C0)
/u_adder7: IC39.10 (S4), IC80.10 (2C0)
/u_adder8: IC40.4 (S1), IC81.6 (1C0)
/u_adder9: IC40.1 (S2), IC81.10 (2C0)
/u_adder10: IC40.13 (S3), IC82.6 (1C0)
/u_adder11: IC40.10 (S4), IC82.10 (2C0)
/u_adder12: IC41.4 (S1), IC83.6 (1C0)
/u_adder13: IC41.1 (S2), IC83.10 (2C0)
/u_cf: IC14.4 (1C2), IC18.6 (1C0), IC22.5 (Q2), IC28.3 (D1), IC30.6 (2B)
/u_of: IC20.2 (1A), IC22.9 (Q4), IC30.13 (4B)
/u_sf: IC19.2 (1A), IC22.6 (Q3), IC30.10 (3B), IC_86_1.9 (I0)
/u_zf: IC13.2 (I1), IC17.6 (1C0), IC22.2 (Q1), IC30.3 (1B)
/w0: IC11.2 (1A), IC114.3 (1D), IC115.2 (A1), IC166.7 (1Y)
/w1: IC11.5 (2A), IC114.4 (2D), IC115.4 (A2), IC166.9 (2Y)
/w2: IC11.11 (3A), IC114.7 (3D), IC115.6 (A3), IC167.7 (1Y)
/w3: IC11.14 (4A), IC114.8 (4D), IC115.8 (A4), IC167.9 (2Y)
/w4: IC12.2 (1A), IC114.13 (5D), IC115.11 (A1), IC168.7 (1Y)
/w5: IC12.5 (2A), IC114.14 (6D), IC115.13 (A2), IC168.9 (2Y)
/w6: IC12.11 (3A), IC114.17 (7D), IC115.15 (A3), IC169.7 (1Y)
/w7: IC12.14 (4A), IC114.18 (8D), IC115.17 (A4), IC169.9 (2Y)
/xbus0: ALU_LOW1.2 (A0), IC11.4 (1Y)
/xbus1: ALU_LOW1.23 (A1), IC11.7 (2Y)
/xbus2: ALU_LOW1.21 (A2), IC11.9 (3Y)
/xbus3: ALU_LOW1.19 (A3), IC11.12 (4Y)
/xbus4: ALU_HIGH1.2 (A0), IC12.4 (1Y)
/xbus5: ALU_HIGH1.23 (A1), IC12.7 (2Y)
/xbus6: ALU_HIGH1.21 (A2), IC12.9 (3Y)
/xbus7: ALU_HIGH1.19 (A3), IC12.12 (4Y), IC_86_2.2 (I1), IC_86_2.4 (I0)
/ybus0: ALU_LOW1.1 (B0), IC15.4 (1Y)
/ybus1: ALU_LOW1.22 (B1), IC15.7 (2Y)
/ybus2: ALU_LOW1.20 (B2), IC15.9 (3Y)
/ybus3: ALU_LOW1.18 (B3), IC15.12 (4Y)
/ybus4: ALU_HIGH1.1 (B0), IC16.4 (1Y)
/ybus5: ALU_HIGH1.22 (B1), IC16.7 (2Y)
/ybus6: ALU_HIGH1.20 (B2), IC16.9 (3Y)
/ybus7: ALU_HIGH1.18 (B3), IC16.12 (4Y), IC_86_2.5 (I1)
/zbus0: IC1.3 (1D), IC2.3 (1D), IC36.3 (1D), IC47.18 (Y1), IC51.1 (I0), IC54.3 (1D), IC55.3 (1D), IC56.3 (1D), IC57.3 (1D), IC58.3 (1D), IC59.3 (1D), IC60.3 (1D), IC61.3 (1D), IC62.3 (1D), IC63.3 (1D), IC64.3 (1D), IC65.3 (1D), IC66.3 (1D), IC67.3 (1D), IC68.3 (1D), IC69.3 (1D), IC70.3 (1D), IC71.3 (1D), IC72.3 (1D), IC73.3 (1D), IC74.3 (1D), IC84.3 (1D), IC85.3 (1D), IC87.3 (1C3), IC181.2 (1A), IC183.2 (1A), IC195.3 (1D), MDR_IN_MUX_1.2 (1A)
/zbus1: IC1.4 (2D), IC2.4 (2D), IC36.4 (2D), IC47.16 (Y2), IC51.2 (I1), IC54.4 (2D), IC55.4 (2D), IC56.4 (2D), IC57.4 (2D), IC58.4 (2D), IC59.4 (2D), IC60.4 (2D), IC61.4 (2D), IC62.4 (2D), IC63.4 (2D), IC64.4 (2D), IC65.4 (2D), IC66.4 (2D), IC67.4 (2D), IC68.4 (2D), IC69.4 (2D), IC70.4 (2D), IC71.4 (2D), IC72.4 (2D), IC73.4 (2D), IC74.4 (2D), IC84.4 (2D), IC85.4 (2D), IC88.1 (D3), IC181.5 (2A), IC183.5 (2A), IC195.4 (2D), MDR_IN_MUX_1.5 (2A)
/zbus2: IC1.7 (3D), IC2.7 (3D), IC36.7 (3D), IC47.14 (Y3), IC51.13 (I2), IC54.7 (3D), IC55.7 (3D), IC56.7 (3D), IC57.7 (3D), IC58.7 (3D), IC59.7 (3D), IC60.7 (3D), IC61.7 (3D), IC62.7 (3D), IC63.7 (3D), IC64.7 (3D), IC65.7 (3D), IC66.7 (3D), IC67.7 (3D), IC68.7 (3D), IC69.7 (3D), IC70.7 (3D), IC71.7 (3D), IC72.7 (3D), IC73.7 (3D), IC74.7 (3D), IC84.7 (3D), IC85.7 (3D), IC89.3 (1C3), IC181.11 (3A), IC183.11 (3A), IC195.7 (3D), MDR_IN_MUX_1.11 (3A)
/zbus3: IC1.8 (4D), IC2.8 (4D), IC36.8 (4D), IC47.12 (Y4), IC51.3 (I0), IC54.8 (4D), IC55.8 (4D), IC56.8 (4D), IC57.8 (4D), IC58.8 (4D), IC59.8 (4D), IC60.8 (4D), IC61.8 (4D), IC62.8 (4D), IC63.8 (4D), IC64.8 (4D), IC65.8 (4D), IC66.8 (4D), IC67.8 (4D), IC68.8 (4D), IC69.8 (4D), IC70.8 (4D), IC71.8 (4D), IC72.8 (4D), IC73.8 (4D), IC74.8 (4D), IC84.8 (4D), IC85.8 (4D), IC90.1 (D3), IC181.14 (4A), IC183.14 (4A), IC195.8 (4D), MDR_IN_MUX_1.14 (4A)
/zbus4: IC1.13 (5D), IC2.13 (5D), IC36.13 (5D), IC47.9 (Y1), IC51.4 (I1), IC54.13 (5D), IC55.13 (5D), IC56.13 (5D), IC57.13 (5D), IC58.13 (5D), IC59.13 (5D), IC60.13 (5D), IC61.13 (5D), IC62.13 (5D), IC63.13 (5D), IC64.13 (5D), IC65.13 (5D), IC66.13 (5D), IC67.13 (5D), IC68.13 (5D), IC69.13 (5D), IC70.13 (5D), IC71.13 (5D), IC72.13 (5D), IC73.13 (5D), IC74.13 (5D), IC84.13 (5D), IC85.13 (5D), IC93.3 (1B), IC182.2 (1A), IC184.2 (1A), IC195.13 (5D), MDR_IN_MUX_2.2 (1A)
/zbus5: IC1.14 (6D), IC2.14 (6D), IC36.14 (6D), IC47.7 (Y2), IC51.5 (I2), IC54.14 (6D), IC55.14 (6D), IC56.14 (6D), IC57.14 (6D), IC58.14 (6D), IC59.14 (6D), IC60.14 (6D), IC61.14 (6D), IC62.14 (6D), IC63.14 (6D), IC64.14 (6D), IC65.14 (6D), IC66.14 (6D), IC67.14 (6D), IC68.14 (6D), IC69.14 (6D), IC70.14 (6D), IC71.14 (6D), IC72.14 (6D), IC73.14 (6D), IC74.14 (6D), IC84.14 (6D), IC85.14 (6D), IC93.6 (2B), IC182.5 (2A), IC184.5 (2A), IC195.14 (6D), MDR_IN_MUX_2.5 (2A)
/zbus6: IC1.17 (7D), IC2.17 (7D), IC36.17 (7D), IC47.5 (Y3), IC51.9 (I0), IC54.17 (7D), IC55.17 (7D), IC56.17 (7D), IC57.17 (7D), IC58.17 (7D), IC59.17 (7D), IC60.17 (7D), IC61.17 (7D), IC62.17 (7D), IC63.17 (7D), IC64.17 (7D), IC65.17 (7D), IC66.17 (7D), IC67.17 (7D), IC68.17 (7D), IC69.17 (7D), IC70.17 (7D), IC71.17 (7D), IC72.17 (7D), IC73.17 (7D), IC74.17 (7D), IC84.17 (7D), IC85.17 (7D), IC93.10 (3B), IC182.11 (3A), IC184.11 (3A), IC195.17 (7D), MDR_IN_MUX_2.11 (3A)
/zbus7: IC1.18 (8D), IC2.18 (8D), IC19.3 (1B), IC36.18 (8D), IC47.3 (Y4), IC51.10 (I1), IC54.18 (8D), IC55.18 (8D), IC56.18 (8D), IC57.18 (8D), IC58.18 (8D), IC59.18 (8D), IC60.18 (8D), IC61.18 (8D), IC62.18 (8D), IC63.18 (8D), IC64.18 (8D), IC65.18 (8D), IC66.18 (8D), IC67.18 (8D), IC68.18 (8D), IC69.18 (8D), IC70.18 (8D), IC71.18 (8D), IC72.18 (8D), IC73.18 (8D), IC74.18 (8D), IC84.18 (8D), IC85.18 (8D), IC89.5 (1C1), IC90.2 (D2), IC93.13 (4B), IC182.14 (4A), IC184.14 (4A), IC195.18 (8D), IC_86_1.10 (I1), IC_86_2.1 (I0), MDR_IN_MUX_2.14 (4A)
/~addr_bus_7_to_14_alltrue: IC122.4 (I2), IC162.8 (O), IC163.3 (I)
/~clear_all_irqs: IC43.2 (O), IC193.4 (O), IRQ_AND_1.1 (I0), IRQ_AND_1.4 (I0), IRQ_AND_1.5 (I1), IRQ_AND_1.9 (I0), IRQ_AND_1.10 (I1), IRQ_AND_1.12 (I0), IRQ_AND_1.13 (I1), IRQ_AND_2.1 (I0), IRQ_AND_2.2 (I1), IRQ_AND_2.4 (I0), IRQ_AND_2.5 (I1), IRQ_AND_2.9 (I0), IRQ_AND_2.10 (I1), IRQ_AND_2.12 (I0), IRQ_AND_2.13 (I1), IRQ_RST_DECODER1.7 (Y7), IRQ_RST_DECODER1.9 (Y6), IRQ_RST_DECODER1.10 (Y5), IRQ_RST_DECODER1.11 (Y4), IRQ_RST_DECODER1.12 (Y3), IRQ_RST_DECODER1.13 (Y2), IRQ_RST_DECODER1.14 (Y1)
GND: ALU_HIGH1.12 (GND), ALU_LOW1.12 (GND), BIOS_ROM1.1 (A15), DIS1.4 (DP-L), DIS1.5 (L-SI), DIS1.7 (GND), DIS1.8 (BI), DIS1.10 (DP-R), DIS2.4 (DP-L), DIS2.5 (L-SI), DIS2.7 (GND), DIS2.8 (BI), DIS2.10 (DP-R), IC3.1 (1G), IC3.15 (2G), IC4.1 (1G), IC4.15 (2G), IC5.1 (1G), IC5.15 (2G), IC6.1 (1G), IC6.15 (2G), IC7.1 (1G), IC7.15 (2G), IC8.1 (1G), IC8.15 (2G), IC9.1 (1G), IC9.15 (2G), IC10.1 (1G), IC10.15 (2G), IC11.15 (G), IC12.15 (G), IC14.1 (1G), IC14.3 (1C3), IC14.10 (2C0), IC14.11 (2C1), IC14.12 (2C2), IC14.13 (2C3), IC14.15 (2G), IC15.15 (G), IC16.15 (G), IC17.1 (1G), IC17.3 (1C3), IC17.10 (2C0), IC17.11 (2C1), IC17.12 (2C2), IC17.13 (2C3), IC17.15 (2G), IC18.1 (1G), IC18.10 (2C0), IC18.11 (2C1), IC18.12 (2C2), IC18.13 (2C3), IC18.15 (2G), IC19.5 (2A), IC19.6 (2B), IC19.10 (3B), IC19.11 (3A), IC19.13 (4B), IC19.14 (4A), IC19.15 (G), IC20.5 (2A), IC20.6 (2B), IC20.10 (3B), IC20.11 (3A), IC20.13 (4B), IC20.14 (4A), IC20.15 (G), IC22.13 (D5), IC22.14 (D6), IC22.17 (D7), IC22.18 (D8), IC24.5 (2A), IC24.11 (3A), IC24.14 (4A), IC24.15 (G), IC25.2 (1A), IC25.5 (2A), IC25.11 (3A), IC25.14 (4A), IC25.15 (G), IC26.2 (1A)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
unnamed: ALU_HIGH1.7 (CN), ALU_LOW1.16 (CN+4)
unnamed: ALU_LOW1.7 (CN), IC_86_1.3 (O)
unnamed: BIOS_ROM1.10 (A0), IC172.18 (Y1), KM62256CLP1.10 (A0)
unnamed: BIOS_ROM1.9 (A1), IC172.16 (Y2), KM62256CLP1.9 (A1)
unnamed: BIOS_ROM1.8 (A2), IC172.14 (Y3), KM62256CLP1.8 (A2)
unnamed: BIOS_ROM1.7 (A3), IC172.12 (Y4), IC199.1 (A), KM62256CLP1.7 (A3)
unnamed: BIOS_ROM1.6 (A4), IC116.1 (A), IC172.9 (Y1), KM62256CLP1.6 (A4)
unnamed: BIOS_ROM1.5 (A5), IC116.2 (B), IC172.7 (Y2), KM62256CLP1.5 (A5)
unnamed: BIOS_ROM1.4 (A6), IC116.3 (C), IC172.5 (Y3), KM62256CLP1.4 (A6)
unnamed: BIOS_ROM1.3 (A7), IC162.12 (I7), IC172.3 (Y4), KM62256CLP1.3 (A7)
unnamed: BIOS_ROM1.25 (A8), IC162.11 (I6), IC173.18 (Y1), KM62256CLP1.25 (A8)
unnamed: BIOS_ROM1.24 (A9), IC162.6 (I5), IC173.16 (Y2), KM62256CLP1.24 (A9)
unnamed: BIOS_ROM1.21 (A10), IC162.5 (I4), IC173.14 (Y3), KM62256CLP1.21 (A10)
unnamed: BIOS_ROM1.23 (A11), IC162.4 (I3), IC173.12 (Y4), KM62256CLP1.23 (A11)
unnamed: BIOS_ROM1.2 (A12), IC162.3 (I2), IC173.9 (Y1), KM62256CLP1.2 (A12)
unnamed: BIOS_ROM1.26 (A13), IC162.2 (I1), IC173.7 (Y2), KM62256CLP1.26 (A13)
unnamed: BIOS_ROM1.27 (A14), IC162.1 (I0), IC173.5 (Y3), KM62256CLP1.1 (A14)
unnamed: BIOS_ROM1.11 (O0), IC110.18 (B1), KM62256CLP1.11 (Q0)
unnamed: BIOS_ROM1.12 (O1), IC110.17 (B2), KM62256CLP1.12 (Q1)
unnamed: BIOS_ROM1.13 (O2), IC110.16 (B3), KM62256CLP1.13 (Q2)
unnamed: BIOS_ROM1.15 (O3), IC110.15 (B4), KM62256CLP1.15 (Q3)
unnamed: BIOS_ROM1.16 (O4), IC110.14 (B5), KM62256CLP1.16 (Q4)
unnamed: BIOS_ROM1.17 (O5), IC110.13 (B6), KM62256CLP1.17 (Q5)
unnamed: BIOS_ROM1.18 (O6), IC110.12 (B7), KM62256CLP1.18 (Q6)
unnamed: BIOS_ROM1.19 (O7), IC110.11 (B8), KM62256CLP1.19 (Q7)
unnamed: BIOS_ROM1.20 (~CE), IC_10_2.8 (O)
unnamed: FLAGS1.3 (D1), IC87.7 (1Y)
unnamed: FLAGS1.4 (D2), IC88.5 (Y)
unnamed: FLAGS1.7 (D3), IC89.7 (1Y)
unnamed: FLAGS1.8 (D4), IC90.5 (Y)
unnamed: FLAGS1.13 (D5), IC93.4 (1Y)
unnamed: FLAGS1.14 (D6), IC93.7 (2Y)
unnamed: FLAGS1.17 (D7), IC93.9 (3Y)
unnamed: FLAGS1.18 (D8), IC93.12 (4Y)
unnamed: IC1.2 (1Q), IC3.4 (1C2)
unnamed: IC1.5 (2Q), IC3.12 (2C2)
unnamed: IC1.6 (3Q), IC4.4 (1C2)
unnamed: IC1.9 (4Q), IC4.12 (2C2)
unnamed: IC1.12 (5Q), IC5.4 (1C2)
unnamed: IC1.15 (6Q), IC5.12 (2C2)
unnamed: IC1.16 (7Q), IC6.4 (1C2)
unnamed: IC1.19 (8Q), IC6.12 (2C2)
unnamed: IC2.2 (1Q), IC3.3 (1C3)
unnamed: IC2.5 (2Q), IC3.13 (2C3)
unnamed: IC2.6 (3Q), IC4.3 (1C3)
unnamed: IC2.9 (4Q), IC4.13 (2C3)
unnamed: IC2.12 (5Q), IC5.3 (1C3)
unnamed: IC2.15 (6Q), IC5.13 (2C3)
unnamed: IC2.16 (7Q), IC6.3 (1C3)
unnamed: IC2.19 (8Q), IC6.13 (2C3)
unnamed: IC3.7 (1Y), IC11.3 (1B)
unnamed: IC3.9 (2Y), IC11.6 (2B)
unnamed: IC4.7 (1Y), IC11.10 (3B)
unnamed: IC4.9 (2Y), IC11.13 (4B)
unnamed: IC5.7 (1Y), IC12.3 (1B)
unnamed: IC5.9 (2Y), IC12.6 (2B)
unnamed: IC6.7 (1Y), IC12.10 (3B)
unnamed: IC6.9 (2Y), IC12.13 (4B)
unnamed: IC13.3 (O), IC17.4 (1C2)
unnamed: IC13.5 (I1), IC13.9 (I0), IC21.8 (O)
unnamed: IC13.8 (O), IC48.5 (I1)
unnamed: IC13.13 (I1), IC48.6 (O)
unnamed: IC14.7 (1Y), IC_86_1.1 (I0)
unnamed: IC17.7 (1Y), IC22.3 (D1)
unnamed: IC18.7 (1Y), IC22.4 (D2)
unnamed: IC19.4 (1Y), IC22.7 (D3)
unnamed: IC20.4 (1Y), IC22.8 (D4)
unnamed: IC21.2 (O), IC23.2 (I1)
unnamed: IC21.4 (O), IC23.13 (I2)
unnamed: IC23.12 (O), IC24.1 (~A/B), IC25.1 (~A/B), IC26.1 (~A/B), IC27.1 (~A/B)
unnamed: IC24.4 (1Y), IC38.6 (B1)
unnamed: IC24.7 (2Y), IC38.2 (B2)
unnamed: IC24.9 (3Y), IC38.15 (B3)
unnamed: IC24.12 (4Y), IC38.11 (B4)
unnamed: IC25.4 (1Y), IC39.6 (B1)
unnamed: IC25.7 (2Y), IC39.2 (B2)
unnamed: IC25.9 (3Y), IC39.15 (B3)
unnamed: IC25.12 (4Y), IC39.11 (B4)
unnamed: IC26.4 (1Y), IC40.6 (B1)
unnamed: IC26.7 (2Y), IC40.2 (B2)
unnamed: IC26.9 (3Y), IC40.15 (B3)
unnamed: IC26.12 (4Y), IC40.11 (B4)
unnamed: IC27.4 (1Y), IC41.6 (B1)
unnamed: IC27.7 (2Y), IC41.2 (B2)
unnamed: IC28.5 (Y), IC31.4 (1C2), IC34.11 (2C1)
unnamed: IC29.3 (O), IC29.4 (I0)
unnamed: IC30.4 (1Y), IC44.5 (I1), IC45.5 (I1), IC49.4 (D0)
unnamed: IC30.7 (2Y), IC45.4 (I0), IC49.3 (D1)
unnamed: IC30.9 (3Y), IC37.4 (I0), IC49.2 (D2)
unnamed: IC30.12 (4Y), IC37.5 (I1), IC49.1 (D3)
unnamed: IC31.7 (1Y), IC47.2 (A1)
unnamed: IC31.9 (2Y), IC47.4 (A2)
unnamed: IC32.7 (1Y), IC47.6 (A3)
unnamed: IC32.9 (2Y), IC47.8 (A4)
unnamed: IC33.7 (1Y), IC47.11 (A1)
unnamed: IC33.9 (2Y), IC47.13 (A2)
unnamed: IC34.7 (1Y), IC47.15 (A3)
unnamed: IC34.9 (2Y), IC47.17 (A4)
unnamed: IC37.6 (O), IC44.4 (I0), IC49.15 (D4)
unnamed: IC38.9 (C4), IC39.7 (C0)
unnamed: IC39.9 (C4), IC40.7 (C0)
unnamed: IC40.9 (C4), IC41.7 (C0)
unnamed: IC43.4 (O), WD1.13 (~MR)
unnamed: IC44.6 (O), IC49.14 (D5)
unnamed: IC45.6 (O), IC49.13 (D6)
unnamed: IC46.3 (O), IRQ_ENCODER1.4 (7)
unnamed: IC46.6 (O), IRQ_ENCODER1.3 (6)
unnamed: IC46.8 (O), IRQ_ENCODER1.2 (5)
unnamed: IC46.11 (O), IRQ_ENCODER1.1 (4)
unnamed: IC49.5 (Y), IC76.2 (1A)
unnamed: IC50.5 (Y), IC76.3 (1B)
unnamed: IC51.12 (O), IC75.1 (I0)
unnamed: IC51.6 (O), IC75.2 (I1)
unnamed: IC51.8 (O), IC75.13 (I2)
unnamed: IC52.3 (O), IRQ_ENCODER1.13 (3)
unnamed: IC52.6 (O), IRQ_ENCODER1.12 (2)
unnamed: IC52.8 (O), IRQ_ENCODER1.11 (1)
unnamed: IC52.11 (O), IRQ_ENCODER1.10 (0)
unnamed: IC53.3 (O), IC84.1 (G)
unnamed: IC53.6 (O), IC85.1 (G)
unnamed: IC75.6 (O), IC87.4 (1C2)
unnamed: IC77.7 (1Y), IC91.3 (D1)
unnamed: IC77.9 (2Y), IC91.4 (D2)
unnamed: IC78.7 (1Y), IC91.7 (D3)
unnamed: IC78.9 (2Y), IC91.8 (D4)
unnamed: IC79.7 (1Y), IC91.13 (D5)
unnamed: IC79.9 (2Y), IC91.14 (D6)
unnamed: IC80.7 (1Y), IC91.17 (D7)
unnamed: IC80.9 (2Y), IC91.18 (D8)
unnamed: IC81.7 (1Y), IC92.3 (D1)
unnamed: IC81.9 (2Y), IC92.4 (D2)
unnamed: IC82.7 (1Y), IC92.7 (D3)
unnamed: IC82.9 (2Y), IC92.8 (D4)
unnamed: IC83.7 (1Y), IC92.13 (D5)
unnamed: IC83.9 (2Y), IC92.14 (D6)
unnamed: IC90.15 (D4), IC_86_1.8 (O)
unnamed 536: U_ROM1.11 (O0); also elsewhere on the board
unnamed 537: U_ROM1.12 (O1); also elsewhere on the board
unnamed 538: U_ROM1.13 (O2); also elsewhere on the board
unnamed 539: U_ROM1.15 (O3); also elsewhere on the board
unnamed 540: U_ROM1.16 (O4); also elsewhere on the board
unnamed 541: U_ROM1.17 (O5); also elsewhere on the board
unnamed 542: U_ROM1.18 (O6); also elsewhere on the board
unnamed 543: U_ROM1.19 (O7); also elsewhere on the board
unnamed 544: U_ROM2.11 (O0); also elsewhere on the board
unnamed 545: U_ROM2.12 (O1); also elsewhere on the board
unnamed 546: U_ROM2.13 (O2); also elsewhere on the board
unnamed 547: U_ROM2.15 (O3); also elsewhere on the board
unnamed 548: U_ROM2.16 (O4); also elsewhere on the board
unnamed 549: U_ROM2.17 (O5); also elsewhere on the board
unnamed 550: U_ROM2.18 (O6); also elsewhere on the board
unnamed: IC96.3 (D1), U_ROM3.11 (O0)
unnamed: IC96.4 (D2), U_ROM3.12 (O1)
unnamed: IC96.7 (D3), U_ROM3.13 (O2)
unnamed: IC96.8 (D4), U_ROM3.15 (O3)
unnamed: IC96.13 (D5), U_ROM3.16 (O4)
unnamed: IC96.14 (D6), U_ROM3.17 (O5)
unnamed: IC96.17 (D7), U_ROM3.18 (O6)
unnamed: IC96.18 (D8), U_ROM3.19 (O7)
unnamed: IC97.3 (D1), U_ROM4.11 (O0)
unnamed: IC97.4 (D2), U_ROM4.12 (O1)
unnamed: IC97.7 (D3), U_ROM4.13 (O2)
unnamed: IC97.8 (D4), U_ROM4.15 (O3)
unnamed: IC97.13 (D5), U_ROM4.16 (O4)
unnamed: IC97.14 (D6), U_ROM4.17 (O5)
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
Notes on the sheet:
marh
halt: use the halt flag to tri-state all buses. do microcode loop to test for interrupts or dma. if no interrupts or dma then just perform tight loop of zero offset. when int or dma appears, jump +1. next microinstr is pre-fetch type, so that int or dma can be executed. pc will be pointing to after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
this comes from the microcode board but is not a control bit. it is a combination of two bits.
bph
rewiring the a1/a27 of the roms will be difficult and could damage the wiring and destroy the board.
IMPROVE THIS PART OF THE CIRCUIT
alu_op == add
mdr mux
adder
removed trace_mode flag from here. (no longer exists)
low
marl
microcode 0 to 63 is reserved for cpu startup. fetch at 0x10 trap at 0x20
if type = branch, and condition = false, then next = +1
carry in mux
this is the positive edge version of the master reset signal
int_pending input to conditional is to be used with halt instruction to check if ints are pending. it is also used with the cpu trace mode so that when coming out of the trace microcode loop, we can jump to the interrupts handler if interrupts are pending. without the int_pending conditional it is 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
single step clock
HEAD LOAD (Option for double-sided version only) This signal line is used either HEAD LOAD or IN USE. When this signal is low, R/W head loads against the diskette. The set-up time of the solenoid is recuired before using this signal. This signal line responds to the input signal regardless of DRIVE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
unused signals
status
microcode sequencing
to calculate of when doing shifts we first save the sign of the original number, then when done shifting we save the value of the result. then we do a xor of both values, and the result is the of. the result of the xor is the msb of the result (zbus7). this is why wehave zbus7 as one of the inputs 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
ptb
front panel register display
512kb ram modules. 8 modules giving a total of 4mb
244 microcode signals need inverter because they get reset to zero at beginning, and 244 are low active. this causes problems on reset.
add mux here to create esc opcode
shl: msb goes into cf. lsb replaced by 0 sla: same as shl rol: lsb becomes msb. rlc: msb goes into cf. lsb becomes cf shr: lsb goes into cf. msb replaced by 0 sra: lsb goes into cf. msb is whatever the previous one was ror: msb becomes lsb rrc: msb becomes cf. lsb goes into cf
pcl
74HCT244 is used here because it recognizes TTL input levels. ttl levels are lower than CMOS, and the esp works at 3.3V. so when a high level is generated by the esp, it will go thru the HCT and it will trconize it as a high, whereas a niejjA
lt lte ~lt = gte ~lte + gt
g_h
0 = kernel 1 = user
unused
u_flags
sih
irq masks
alu_mode removed. of is undefined if alu in logic mode anyway.
ssph

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